# Keil uVision project First_Test.uvprojx, settings and files
target First_Test (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L431RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: First_Test +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L431xx
  c include: ../Inc;      ../Drivers/STM32L4xx_HAL_Driver/Inc;      ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;      ../Drivers/CMSIS/Device/ST/STM32L4xx/Include;      ../Drivers/CMSIS/Include;      ..\..\..\arch\arm\arm-v7m\common\include;      ..\..\..\arch\arm\arm-v7m\cortex-m4\armcc;      ..\..\..\kernel\core\include;      ..\..\..\kernel\pm\include;      ..\..\..\osal\cmsis_os;      ..\..\..\TOS_CONFIG;      ..\Hardware;      ..\Hardware\MultiButton;      ..\..\..\device\esp8266;      ..\..\..\net\at\include;      ..\..\..\net\sal_module_wrapper;      ..\..\..\net\socket_wrapper\include;      ..\..\..\kernel\hal\include;      ..\..\..\platform\hal\st\stm32l4xx\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32l431xx.s
  group Application/User
    ../Src/: demo.c main.c gpio.c i2c.c usart.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Hardware
    ../Hardware/: oled.c
    ../Hardware/MultiButton/: multi_button.c
  group tos/at
    ../../../net/at/src/: tos_at.c
  group tos/hal
    ../../../platform/hal/st/stm32l4xx/src/: tos_hal_uart.c
  group tos/arch
    ../../../arch/arm/arm-v7m/common/: tos_cpu.c
    ../../../arch/arm/arm-v7m/cortex-m4/armcc/: port_c.c port_s.S
  group tos/config
    ../../../TOS_CONFIG/: tos_config.h
  group tos/kernel
    ../../../kernel/core/: tos_barrier.c tos_binary_heap.c tos_bitmap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_event.c tos_global.c tos_mail_queue.c tos_message_queue.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_robin.c tos_rwlock.c tos_sched.c tos_sem.c tos_stopwatch.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c
  group tos/devices
    ../../../device/esp8266/: esp8266.c
  group tos/cmsis_os
    ../../../osal/cmsis_os/: cmsis_os.c
  group tos/socket_wrapper
    ../../../net/socket_wrapper/: tos_at_socket.c tos_at_socket_lib.c tos_at_socket_prv.c
  group tos/sal_module_wrapper
    ../../../net/sal_module_wrapper/: sal_module_wrapper.c
software components: CMSIS:CORE 4.3.0
